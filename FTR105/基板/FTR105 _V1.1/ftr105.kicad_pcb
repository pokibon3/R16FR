# Repository pokibon3/R16FR

## KiCad design FTR105/基板/FTR105 _V1.1/ftr105.kicad_pcb

Parts:
AF_GAIN1: 10KB; TSR-3386T
C1: 0.01u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2, C9: 0.22u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3, C4, C5, C6, C11, C12, C13, C15: 10u; CP_Radial_D5.0mm_P2.00mm
C7, C10: 470u; CP_Radial_D8.0mm_P3.50mm
C8, C14: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C16: 4700p; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1: OS5RKA5111P; LED_D5.0mm_Horizontal_O3.81mm_Z3.0mm
D2: S7183; LED_Rectangular_W5.0mm_H2.0mm
D3: LED; LED_D3.0mm
J1: KEY_IN; Jack_3.5mm_Switronic_ST-005-G_horizontal
J2: SP; PinHeader_1x02_P2.54mm_Vertical
J3: VCC5V; PinHeader_1x02_P2.54mm_Vertical
J4: HEAD_SET; MJ-4PP-9
MIC_GAIN1: 1kB; TSR-3386T
Q1, Q2: 2SC1815; TO-92_Inline_Wide
R1, R6, R7, R13: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2, R5, R8, R9: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3, R12: 3.3k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4, R11: R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R10: 220k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R14, R15: 47; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R16: 1; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
SW1: PTT; SW_PUSH-12mm
SW2: POWER; SK-12D11VG3
SW3: MODE; SW_CuK_JS202011AQN_DPDT_Angled
U1: XD555; DIP-8_W7.62mm
U2: LM358; DIP-8_W7.62mm
U3: 2073D; DIP-8_W7.62mm

Connections:
GND: AF_GAIN1.3, C1.2, C3.2, C5.2, C6.2, C7.2, C8.2, C11.2, C12.2, D3.1 (K), J1.S, J2.2, J3.2, J4.2 (B), Q1.1 (E), R7.2, R11.1, R16.1, SW1.1, SW3.2 (B), U1.1 (GND), U2.4 (V-), U3.4 (GND); also elsewhere on the board
unnamed 1: AF_GAIN1.1, C4.2; also elsewhere on the board
unnamed: C1.1, SW3.4 (A)
unnamed: C2.2, SW3.1 (A)
unnamed: C3.1, D2.1 (K), Q2.1 (E)
unnamed: C4.1, D2.2 (A), R11.2
unnamed: C5.1, Q2.3 (B), R13.1
unnamed: C6.1, U3.5 (INB-)
unnamed: C9.2, R16.2
unnamed: C9.1, C10.1, U3.3 (OUTB)
unnamed: C10.2, J2.1, R14.1, R15.1
unnamed 11: C11.1, MIC_GAIN1.3, R5.1; also elsewhere on the board
unnamed: C12.1, R6.2, R7.1, U2.3 (+)
unnamed 13: C13.1, MIC_GAIN1.2; also elsewhere on the board
unnamed: C13.2, C14.2, R9.1
unnamed: C14.1, R9.2, R10.1, U2.6 (-)
unnamed: C15.1, SW3.6 (C)
unnamed: C15.2, R10.2, U2.7
unnamed: C2.1, C16.1, Q1.2 (C), R3.1, U1.2 (TR), U1.6 (THR)
unnamed: C16.2, SW3.3 (C)
unnamed: D1.1 (K), R4.2
unnamed: D3.2 (A), R12.2
unnamed: J1.T, Q1.3 (B), R1.2, SW1.2
unnamed: J3.1, SW2.2 (B)
unnamed 24: J4.1 (A), MIC_GAIN1.1; also elsewhere on the board
unnamed: J4.3 (C), R15.2
unnamed: J4.4 (D), R14.2
unnamed: R2.1, R3.2, U1.7 (DIS)
unnamed: R4.1, U1.3 (Q)
unnamed: R8.1, U2.1, U2.2 (-)
unnamed: R8.2, U2.5 (+)
unnamed: SW3.5 (B), U1.5 (CV)
unnamed 32: AF_GAIN1.2, U3.6 (INB+); also elsewhere on the board
VCC: C7.1, C8.1, D1.2 (A), Q2.2 (C), R1.1, R2.2, R5.2, R6.1, R12.1, R13.2, SW2.1 (A), U1.4 (R), U1.8 (VCC), U2.8 (V+), U3.2 (VCC)

Notes on the sheet:
未実装

Board: 2 copper layers, 72.0 x 47.0 mm, 49 parts (0 on the bottom side), 34 nets.

Other parts of the board:
AF_GAIN: 10KB; TSR-3386T
MIC_GAIN: 1kB; TSR-3386T

Their connections:
GND: AF_GAIN.3; also elsewhere on the board
unnamed 1: AF_GAIN.1; also elsewhere on the board
unnamed 11: MIC_GAIN.3; also elsewhere on the board
unnamed 13: MIC_GAIN.2; also elsewhere on the board
unnamed 24: MIC_GAIN.1; also elsewhere on the board
unnamed 32: AF_GAIN.2; also elsewhere on the board

## Commit log

2024-01-18 first release
2024-01-18 add KiCad data
